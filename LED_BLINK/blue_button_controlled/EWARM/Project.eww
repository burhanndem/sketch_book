<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\blue_button_controlled.ewp</path>
  </project>
  <batchBuild />
</workspace>
